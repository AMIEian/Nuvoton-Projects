# IAR project fmc_ap_main.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC029AN series Nuvoton NUC029AN series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC029xAN\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: APROM_code.bin
  ILINK.IlinkOutputFile: APROM_code.out
  ILINK.IlinkIcfFile: fmc_ap_main.icf
  ILINK.IlinkExtraOptions: --image_input Release\Exe\LDROM_code.bin,loaderImage1Base,.bin_image,4; --image_input Release\Exe\LDROM_code.bin,loaderImage1Limit,.bin_image,4
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS Files
    ../../../../Library/Device/Nuvoton/NUC029xAN/Source/IAR/: startup_NUC029xAN.s
    ../../../../Library/Device/Nuvoton/NUC029xAN/Source/: system_NUC029xAN.c
  group Library Files
    ../../../../Library/StdDriver/src/: clk.c FMC.c retarget.c sys.c uart.c
  group User
    ../: APROM_main.c
