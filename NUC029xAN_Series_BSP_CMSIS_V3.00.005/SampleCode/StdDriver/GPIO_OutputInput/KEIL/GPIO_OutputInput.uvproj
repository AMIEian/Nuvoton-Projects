# Keil uVision project GPIO_OutputInput.uvproj, settings and files
target GPIO_OutputInput (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: NUC029LAN Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: GPIO_OutputInput
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC029xAN\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\Modbus_Master_LIB
  library: MicroLIB
  link misc: --map --first='startup_NUC029xAN.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029xAN/Source/: system_NUC029xAN.c
    ../../../../Library/Device/Nuvoton/NUC029xAN/Source/ARM/: startup_NUC029xAN.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c gpio.c uart.c clk.c sys.c timer.c
