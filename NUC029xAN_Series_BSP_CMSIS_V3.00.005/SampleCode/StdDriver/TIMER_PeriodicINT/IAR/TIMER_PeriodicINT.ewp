# IAR project TIMER_PeriodicINT.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC029AN series Nuvoton NUC029AN series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\NUC029xAN\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TIMER_PeriodicINT.bin
  ILINK.IlinkOutputFile: TIMER_PeriodicINT.out
  ILINK.IlinkIcfFile: TIMER_PeriodicINT.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC029xAN/Source/IAR/: startup_NUC029xAN.s
    ../../../../Library/Device/Nuvoton/NUC029xAN/Source/: system_NUC029xAN.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c timer.c uart.c
  group User
    ../: main.c
