# Keil uVision project fmc_ld_iap.uvproj, settings and files
target fmc_ld_iap (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: M032SE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(48000000) CPUTYPE("Cortex-M0")
  output: fmc_ld_iap
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group User
    ../: LDROM_main.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c fmc.c
