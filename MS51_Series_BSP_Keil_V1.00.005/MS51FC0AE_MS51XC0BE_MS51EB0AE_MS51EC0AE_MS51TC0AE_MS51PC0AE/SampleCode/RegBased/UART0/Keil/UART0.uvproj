# Keil uVision project UART0.uvproj, settings and files
target UART_mode_1 (MCS-51)
  device: MS51PC0AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: UART0 +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: UART0.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c uart.c timer.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
